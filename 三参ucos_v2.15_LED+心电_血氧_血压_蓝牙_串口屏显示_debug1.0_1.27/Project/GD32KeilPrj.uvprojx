# Keil uVision project GD32KeilPrj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32KeilPrj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\FW\Include;..\App\Main;..\App\Delay;..\App\LED;..\ARM\System;..\App\DataType;..\ARM\NVIC;..\HW\RCU;..\HW\Timer;..\HW\UART0;..\OS\UCOSIII\uC-LIB;..\OS\UCOSIII\uC-CPU;..\OS\UCOSIII\uCOS-BSP;..\OS\UCOSIII\uCOS-CONFIG;..\OS\UCOSIII\uCOS-III\Source;..\OS\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\OS\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\OS\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\App\Filter;..\HW\ADC;..\App\ECG;..\App\SPO2;..\HW\UART1;..\App\NIBP;..\App\PolynomialFit;..\App\Calculate;..\HW\UART2;..\App\Sprintf
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/Main/: Main.c
    ../App/Delay/: Delay.c
    ../App/LED/: LED.c
    ../App/Filter/: Filter.c
    ../App/ECG/: ECG.c
    ../App/SPO2/: SPO2_HW_CFG.c SPO2.c
    ../App/NIBP/: NIBP.c NIBP_HW_CFG.c
    ../App/PolynomialFit/: PolynomialFit.c
    ../App/Calculate/: Calculate.c
    ../App/Sprintf/: Sprintf.c
  group HW
    ../HW/UART0/: Queue.c UART0.c
    ../HW/ADC/: ADC.c
    ../HW/UART1/: UART1.c
    ../HW/UART2/: UART2.c
  group FW
    ../FW/Source/: gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_exmc.c gd32f30x_dma.c gd32f30x_sdio.c gd32f30x_adc.c gd32f30x_dac.c gd32f30x_exti.c
  group ARM
    ../ARM/System/: gd32f30x_it.c system_gd32f30x.c startup_gd32f30x_hd.s
    ../ARM/NVIC/: NVIC.c
  group UCOSIII_BSP
    ../OS/UCOSIII/uCOS-BSP/: bsp.c
  group UCOSIII_CPU
    ../OS/UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../OS/UCOSIII/uC-CPU/: cpu_core.c
  group UCOSIII_LIB
    ../OS/UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../OS/UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../OS/UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../OS/UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII_CONFIG
    ../OS/UCOSIII/uCOS-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
software components: CMSIS:CORE 5.4.0
